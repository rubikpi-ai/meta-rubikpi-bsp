do_compile:append() {
    chmod +w -R ${TMPDIR}
}
