FILESEXTRAPATHS:prepend := "${THISDIR}/android-tools-conf-configfs:"
