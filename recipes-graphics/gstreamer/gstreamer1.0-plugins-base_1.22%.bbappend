PACKAGECONFIG:remove:qcom-custom-bsp = "opengl glx"
