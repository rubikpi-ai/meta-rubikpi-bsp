PACKAGECONFIG:remove:qcom-custom-bsp = "glx"
